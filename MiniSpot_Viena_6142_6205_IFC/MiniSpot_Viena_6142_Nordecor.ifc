Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-05-08T12:09:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 08 12:09:20 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\3a4f5938-171a-400d-a315-b292c7a168d2\614557e5-5751-4c27-8220-7440bcc05156\ifc * Database version: 5507 * Database creation date: Thu May 08 12:09:17 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 08 12:09:17 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 08 12:09:17 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_328277
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 6142, MiniSpot_Viena_6142_6205_Nordecor_IFC:6142:328277
In: Nível 1
Type - Material: LED, Metal - Aluminio -, Metal - Branco, Plástico - Transparente
Type - Cotas - Altura: 60 mm; Comprimento: 80 mm; Largura: 80 mm
Type - Dados - Data de atualização: 07/05/2025; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Spot LED sobrepor Viena, acabamento branco, 10W 3000K 36º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 1 ano; IP: 20; Localização: Camboriú-SC / Brasil; Modelo: 6142; Nome do tipo: 6142; Número OmniClass: 23.80.70.14.11.17; Tipo de imagem: Imagem raster: 6142.png; Título OmniClass: Wall or Ceiling Mounted External Lighting; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/spot-led-sobrepor-viena-10w-3-000k/
Type - Elétrico - Comentários de voltagem: 100-240V; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Luminária: 0 W
Type - Engenharia elétrica - Fator de potência - Luminária: 0.6; Voltagem - Luminária: 0 V
Type - Estrutural - Peso da luminária: 0.408
Type - Fotométricos - Ângulo de abertura: 36 deg; Fluxo luminoso: 1000 lm; IRC: 80; Potência: 10 W; Temperatura de cor: 3000 K
Type - Gráficos - Simbologia: Imagem raster: 6142 2D.png
Type - Materiais e acabamentos - Difusor: Plástico - Transparente; Luminária: Metal - Branco
Type - Outros - Categoria: Luminárias; Branco: yes; Nome da família: MiniSpot_Viena_6142_6205_Nordecor_IFC; Preto: no
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 6142; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Volume: 0.00030291 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: MiniSpot_Viena_6142_6205_Nordecor_IFC: 6142; Família e tipo: MiniSpot_Viena_6142_6205_Nordecor_IFC: 6142; ID de tipo: MiniSpot_Viena_6142_6205_Nordecor_IFC: 6142; Tipo: MiniSpot_Viena_6142_6205_Nordecor_IFC: 6142
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
